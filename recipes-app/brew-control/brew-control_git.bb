require brew-control.inc

SRCREV = "${AUTOREV}"
PV = "git-${SRCPV}"
